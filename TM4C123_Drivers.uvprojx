# Keil uVision project TM4C123_Drivers.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1230H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TM4C123_Drivers +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\appl;..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\common;..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\Config;..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\mcal\Inc;..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\mcal;..\Sprints_ARM_TivaC\Sprints_ARM_MC01\src\mcal\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group appl
    ../Sprints_ARM_TivaC/Sprints_ARM_MC01/src/appl/: MainApp.c S02_CpuUser.c S04_McuUser.c S05_PortUser.c S03_NvicUser.c _01_nvic_user.c S06_AdcUser.c
  group mcal
    ../Sprints_ARM_TivaC/Sprints_ARM_MC01/src/mcal/: Cpu.c Dio.c Mcu.c Nvic.c Port.c ADC.c
  group common
    ../Sprints_ARM_TivaC/Sprints_ARM_MC01/src/common/: Compiler.h mcu_hw.h platform_types.h std_types.h
  group config
    ../Sprints_ARM_TivaC/Sprints_ARM_MC01/src/Config/: Mcu_Lcfg.c Nvic_Lcfg.c Port_Lcfg.c ADC_Lcfg.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.1
